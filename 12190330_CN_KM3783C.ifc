Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-27T09:53:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 27 09:53:22 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f48b3eef-d9a2-4950-9563-5773c556083c\eeb7ceb6-7018-4006-a6b7-2704e5efafe9\ifc * Database version: 5507 * Database creation date: Fri Jan 27 09:53:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 27 09:53:22 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 27 09:53:22 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12190330_CN_KM3783C:26378352_CN_12190330_KM3783C, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_BuildingElementProxyCommon - Reference: 26378352_CN_12190330_KM3783C
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26378352_CN_12190330_KM3783C
Material: z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
